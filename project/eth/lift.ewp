# IAR project lift.ewp, settings and files
configuration MB039 (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; __MM3U1; __MM32_MB039; __MDM2803_N; CLOCK=8000000
  ICCARM.CCIncludePath2: ..\..\bsp\inc; ..\..\driver\inc; ..\..\app\eth\inc; ..\..\lib\HAL_lib\inc; ..\..\lib\startup\inc; ..\..\thirdParty\lwIP\src; ..\..\thirdParty\lwIP\src\arch; ..\..\thirdParty\lwIP\src\include; ..\..\thirdParty\lwIP\src\include\compat; ..\..\thirdParty\lwIP\src\include\netif; ..\..\thirdParty\lwIP\src\include\lwip\; ..\..\thirdParty\lwIP\src\include\lwip\apps; ..\..\thirdParty\lwIP\src\include\lwip\priv; ..\..\thirdParty\lwIP\src\include\lwip\prot
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: MM3N1
  OBJCOPY.OOCOutputFile: se_uid.srec
  ILINK.IlinkOutputFile: uid.out
  ILINK.IlinkIcfFile: lift.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Master (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MM32F3277G7P MindMotion MM32F3277G7P
  ICCARM.CCDefines: __IAR; __MM3U1; __MM32_MB036; __MDM2803; __WIDESCREEN; CLOCK=8000000; __MasterTest
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: lift.srec
  group app
    ../../app/eth/: com.c device.c eth.c hci.c lcd.c main.c master.c
  group bsp
    ../../bsp/: bsp.c bsp_adc.c bsp_beep.c bsp_can.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_eth.c bsp_i2c.c bsp_key.c bsp_lcd.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_phy8720.c bsp_spi.c bsp_tim.c bsp_uart.c
  group lib
    ../../lib/HAL_lib/: common.c HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c hal_eth.c HAL_exti.c HAL_flash.c hal_fsmc.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c hal_sdio.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group system
    ../../lib/startup/: mm32_startup.c mm32_system.c
